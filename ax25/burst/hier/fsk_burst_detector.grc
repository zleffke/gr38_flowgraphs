options:
  parameters:
    category: '[KJ4QLP Hier Blocks]'
    generate_options: hb
    id: fsk_burst_detector
    output_language: python
    title: FSK Burst Detector
  states: {}

blocks:
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      FSK/GMSK
      demodulator
    gain: (samp_rate/decim*interp)/(2*math.pi*fsk_dev/8.0)
  states: {}
- name: avg_len
  id: parameter
  parameters:
    hide: part
    label: Avg Length
    type: eng_float
    value: '100.0'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: cons_offset
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len)
    max_iter: '4000'
    scale: 1.0/avg_len
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '1'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: cons_offset
  id: parameter
  parameters:
    hide: part
    label: Constant Offset
    type: eng_float
    value: '3'
  states: {}
- name: decim
  id: parameter
  parameters:
    hide: part
    label: Decimation
    type: intx
    value: '125'
  states: {}
- name: fsk_dev
  id: parameter
  parameters:
    hide: part
    label: FSK Deviation
    type: eng_float
    value: '10000.0'
  states: {}
- name: interp
  id: parameter
  parameters:
    hide: part
    label: Interpolation
    type: intx
    value: '48'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: trigger
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    hide: part
    label: Sample Rate
    type: eng_float
    value: '250000'
  states: {}

connections:
- [analog_quadrature_demod_cf_1, '0', blocks_skiphead_0, '0']
- [analog_quadrature_demod_cf_1, '0', blocks_sub_xx_0, '0']
- [blocks_abs_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_add_const_vxx_0, '0', pad_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_skiphead_0, '0', blocks_sub_xx_0, '1']
- [blocks_sub_xx_0, '0', blocks_abs_xx_0, '0']
- [pad_source_0, '0', analog_quadrature_demod_cf_1, '0']

metadata:
  file_format: 1
