options:
  parameters:
    author: Zach Leffke, KJ4QLP
    description: VCC Burst TX/RX, 9600 Baud GMSK, AX.25
    generate_options: qt_gui
    id: burst_rx_gmsk9600_ax25_playback
    output_language: python
    title: VCC Burst TX/RX, 9600 Baud GMSK, AX.25, w/ PTT
  states: {}

blocks:
- name: chan_filt_cutoff
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: chan_filt_trans
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: chan_offset
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@1:4,2,1,2
    label: Chan Offset
    type: real
    value: '-40e3'
  states: {}
- name: chan_samp_rate
  id: variable
  parameters:
    value: int(samp_rate / decim*interp / decim_2 * interp_2)
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate/2000)
  states: {}
- name: decim_2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decim_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: chan_cutoff
    gain: '1.0'
    samp_rate: chan_samp_rate
    width: chan_trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: fine_offset
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '0'
  states: {}
- name: fn
  id: variable
  parameters:
    value: '"VCC_{:s}_{:s}".format(gs_id, ts_str)'
  states: {}
- name: fp
  id: variable
  parameters:
    value: '"/vtgs/captures/vcc/{:s}".format(fn)'
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: gs_id
  id: variable
  parameters:
    value: '"VTGS"'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '48'
  states: {}
- name: interp_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rate_factor
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0,1,8
    type: real
    value: '1'
  states: {}
- name: rx_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@0:4,0,1,2
    label: RX Freq
    type: real
    value: 401.08e6
  states: {}
- name: rx_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@0:4,2,1,2
    label: RX Gain
    type: real
    value: '20'
  states: {}
- name: rx_offset
  id: variable
  parameters:
    value: samp_rate/2.0
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: float(250e3)
  states: {}
- name: trigger_thresh
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@1:4,0,1,2
    label: Trigger Thresh
    type: real
    value: '15'
  states: {}
- name: ts_str
  id: variable
  parameters:
    value: dt.strftime(dt.utcnow(), "%Y%m%d_%H%M%S" )
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '10'
    comment: automatic gain control
    decay_rate: '1e-1'
    gain: '1'
    max_gain: 65536 / 10
    reference: 65536 / 10
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: trigger_thresh
    type: float
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Channel Offset
    freq: '-1 * chan_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: VT Freq Offset
    freq: '-1 * fine_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate *interp /decim
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: ax25_gmsk_rx_hier_0
  id: ax25_gmsk_rx_hier
  parameters:
    lpf_cutoff: 12.5e3
    lpf_trans: 1e3
    samp_rate: '250000'
  states: {state: disabled}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst_stop
    false_value: 'False'
    true_key: burst_start
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    comment: Center Channel
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    comment: Center VCC-Ceres
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    minoutbuf: baud*samps_per_symb*2
    tag: est_len
    type: complex
  states: {state: disabled}
- name: blocks_socket_pdu_0_2
  id: blocks_socket_pdu
  parameters:
    comment: |-
      Expects KISS Frames on input
      Sends KISS Frames on output
      <FEND><CMD><DATA><FEND>
      DATA = AX.25 Frame
    host: 0.0.0.0
    mtu: '1024'
    port: '8000'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*rate_factor
    type: complex
  states: {}
- name: burst_rx_es_hier_0
  id: burst_rx_es_hier
  parameters:
    avg_len: '100'
    baud: '9600'
    samp_rate: samp_rate/decim*interp
    samps_per_symb: '10'
    trigger_thresh: trigger_thresh
  states: {state: disabled}
- name: burst_width
  id: parameter
  parameters:
    hide: part
    label: Burst Width [Hz]
    type: intx
    value: int(20e3)
  states: {}
- name: chan_cutoff
  id: parameter
  parameters:
    hide: part
    label: Channel Cutoff
    type: eng_float
    value: 12e3
  states: {}
- name: chan_trans_width
  id: parameter
  parameters:
    hide: part
    label: Channel Trans. Width [cycles/samp]
    type: eng_float
    value: 1e3
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: FFT Size
    type: intx
    value: int(512)
  states: {}
- name: fhss_utils_cf_estimate_0
  id: fhss_utils_cf_estimate
  parameters:
    channel_freqs: '[]'
    method: fhss_utils.HALF_POWER
  states: {}
- name: fhss_utils_fft_burst_tagger_0
  id: fhss_utils_fft_burst_tagger
  parameters:
    burst_post_len: int(round((float(chan_samp_rate)/fft_size)*post_burst_time))
    burst_pre_len: int(round((float(chan_samp_rate)/fft_size)*pre_burst_time))
    burst_width: burst_width
    center_frequency: rx_freq + chan_offset
    debug: 'True'
    fft_size: fft_size
    history_size: int(round((float(samp_rate)/fft_size)*hist_time))
    lookahead: int(round((float(samp_rate)/fft_size)*lookahead_time))
    max_burst_len: '0'
    max_bursts: '0'
    minoutbuf: 2048*1000
    sample_rate: int(samp_rate / decim*interp / decim_2 * interp_2)
    threshold: trigger_thresh
  states: {}
- name: fhss_utils_tagged_burst_to_pdu_0
  id: fhss_utils_tagged_burst_to_pdu
  parameters:
    decimation: '1'
    max_burst_time: max_burst_time
    min_burst_time: min_burst_time
    relative_center_frequency: '0.0'
    relative_sample_rate: '1.0'
    relative_span: '1.0'
    sample_rate: chan_samp_rate
    taps: decim_taps
    threads: '3'
  states: {}
- name: fsk_burst_detector_0
  id: fsk_burst_detector
  parameters:
    avg_len: '100'
    cons_offset: '3'
    decim: decim
    fsk_dev: fsk_dev
    interp: interp
    samp_rate: samp_rate
  states: {}
- name: gmsk_ax25_rx_hier_0
  id: gmsk_ax25_rx_hier
  parameters:
    lpf_cutoff: 7.2e3
    lpf_trans: 1e3
    quad_demod_gain: (samp_rate/decim*interp/decim_2*interp_2)/(2*math.pi*fsk_dev/8.0)
    samp_rate: '48000'
    samps_per_symb: '5'
  states: {state: disabled}
- name: hist_time
  id: parameter
  parameters:
    hide: part
    label: History Time [s]
    type: eng_float
    value: '0.075'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime as dt; import string; import math
  states: {}
- name: lookahead_time
  id: parameter
  parameters:
    hide: part
    label: Lookahead Time [s]
    type: eng_float
    value: '0.01'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Channel Filter
      Wide enough for doppler spread
    cutoff_freq: chan_filt_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decim *interp
    type: fir_filter_ccf
    width: chan_filt_trans
    win: firdes.WIN_HAMMING
  states: {}
- name: main_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,2,8
    label0: Full Band
    label1: RX Channel
    label2: Burst
    num_tabs: '3'
  states: {}
- name: max_burst_time
  id: parameter
  parameters:
    hide: part
    label: Max Burst Time [s]
    type: eng_float
    value: '0.25'
  states: {}
- name: min_burst_time
  id: parameter
  parameters:
    hide: part
    label: Min Burst Time [s]
    type: eng_float
    value: '0.01'
  states: {}
- name: pdu_utils_pdu_fine_time_measure_0
  id: pdu_utils_pdu_fine_time_measure
  parameters:
    average_width: '10'
    buffer_percent: '15'
    post_burst_time: post_burst_time
    pre_burst_time: pre_burst_time
  states: {}
- name: pdu_utils_pdu_split_0
  id: pdu_utils_pdu_split
  parameters:
    pass_empty: 'False'
  states: {}
- name: post_burst_time
  id: parameter
  parameters:
    hide: part
    label: Post Burst Time [s]
    type: eng_float
    value: '0.5'
  states: {}
- name: pre_burst_time
  id: parameter
  parameters:
    hide: part
    label: Pre Burst Time [s]
    type: eng_float
    value: '0.075'
  states: {}
- name: pyqt_meta_text_output_0
  id: pyqt_meta_text_output
  parameters:
    gui_hint: main_tab@1:3,6,4,2
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate*interp/decim*interp_2/decim_2
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@1:0,4,2,4
    label1: '''orig'''
    label2: '''corr'''
    name: '"Burst RX Spectrum"'
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decim*interp / decim_2 * interp_2
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@1:0,0,2,4
    label1: pre-d
    legend: 'False'
    name: '"Channel Spectrum"'
    showports: 'True'
    type: complex
    update_time: '0.0010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '50'
    ymin: '-50'
  states: {}
- name: qtgui_freq_sink_x_1_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@0:0,0,1,8
    label1: pre-d
    legend: 'False'
    name: '"VCC RX Spectrum"'
    showports: 'True'
    type: complex
    update_time: '0.0010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-60'
    ymin: '-130'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: main_tab@2:2,4,1,4
    label1: ''
    label2: ''
    name: '"Threshold"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.010'
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: main_tab@2:0,4,2,4
    size: '1024'
    srate: chan_samp_rate
    tr_delay: '0.005'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst_start"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@0:1,0,1,8
    showports: 'True'
    type: complex
    update_time: '0.0010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim*interp / decim_2 * interp_2
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@1:2,0,2,4
    int_max: '50'
    int_min: '-50'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: chan_samp_rate
    fc: '0'
    fftsize: '128'
    gui_hint: main_tab@1:2,4,2,4
    name: '"Burst Spectrogram"'
    showports: 'True'
    type: msg_complex
    update_time: '0.005'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: reduce to 125k sample rate
    decim: '2'
    fbw: ''
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: reduce to 96k sample rate
    decim: decim
    fbw: ''
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    comment: reduce to 48k sample rate
    decim: decim_2
    fbw: ''
    interp: interp_2
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    comment: reduce to 48k sample rate
    decim: '2'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    comment: reduce to 48k sample rate
    decim: '2'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: sigmf_source_0
  id: sigmf_source
  parameters:
    filename: /home/zleffke/captures/VCC_VTGS_20191123_060818.sigmf-data
    repeat: 'False'
    type: fc32
  states: {}
- name: vcc_qt_hex_text_tx_0
  id: vcc_qt_hex_text
  parameters:
    comment: rx ax.25 frames
    gui_hint: main_tab@1:5,0,2,6
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bursts
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: chan
  states: {}
- name: virtual_sink_rx_kiss
  id: virtual_sink
  parameters:
    stream_id: rx_kiss
  states: {state: disabled}
- name: virtual_sink_tx_kiss
  id: virtual_sink
  parameters:
    stream_id: tx_kiss
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bursts
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: chan
  states: {}
- name: virtual_source_rx_kiss
  id: virtual_source
  parameters:
    stream_id: rx_kiss
  states: {state: disabled}

connections:
- [analog_agc2_xx_0, '0', low_pass_filter_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_burst_tagger_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_xx_0_0_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', ax25_gmsk_rx_hier_0, '0']
- [blocks_socket_pdu_0_2, pdus, virtual_sink_tx_kiss, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [burst_rx_es_hier_0, '0', rational_resampler_xxx_3, '0']
- [burst_rx_es_hier_0, '1', rational_resampler_xxx_2, '0']
- [burst_rx_es_hier_0, meta, pyqt_meta_text_output_0, pdus]
- [fhss_utils_cf_estimate_0, out, pdu_utils_pdu_fine_time_measure_0, pdu_in]
- [fhss_utils_fft_burst_tagger_0, '0', blocks_tag_debug_0, '0']
- [fhss_utils_fft_burst_tagger_0, '0', fhss_utils_tagged_burst_to_pdu_0, '0']
- [fhss_utils_tagged_burst_to_pdu_0, cpdus, fhss_utils_cf_estimate_0, in]
- [fhss_utils_tagged_burst_to_pdu_0, cpdus, pdu_utils_pdu_split_0, pdu_in]
- [fsk_burst_detector_0, '0', blocks_float_to_short_0, '0']
- [fsk_burst_detector_0, '0', qtgui_time_sink_x_0, '0']
- [gmsk_ax25_rx_hier_0, '0', qtgui_freq_sink_x_1, '1']
- [gmsk_ax25_rx_hier_0, kiss, vcc_qt_hex_text_tx_0, pdus]
- [gmsk_ax25_rx_hier_0, kiss, virtual_sink_rx_kiss, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0_0_0, '0']
- [pdu_utils_pdu_fine_time_measure_0, pdu_out, qtgui_waterfall_sink_x_0_1, in]
- [pdu_utils_pdu_fine_time_measure_0, pdu_out, virtual_sink_0, '0']
- [pdu_utils_pdu_split_0, dict, blocks_message_debug_0, print]
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1_0_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', analog_agc2_xx_0, '0']
- [rational_resampler_xxx_1_0, '0', qtgui_freq_sink_x_1_0, '0']
- [rational_resampler_xxx_1_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_1_0, '0', virtual_sink_2, '0']
- [rational_resampler_xxx_2, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_3, '0', gmsk_ax25_rx_hier_0, '0']
- [sigmf_source_0, '0', blocks_throttle_0, '0']
- [virtual_source_0, '0', blocks_pdu_to_tagged_stream_0, pdus]
- [virtual_source_1_0, '0', blocks_burst_tagger_0, '0']
- [virtual_source_1_0, '0', fhss_utils_fft_burst_tagger_0, '0']
- [virtual_source_1_0, '0', fsk_burst_detector_0, '0']
- [virtual_source_rx_kiss, '0', blocks_socket_pdu_0_2, pdus]

metadata:
  file_format: 1
