options:
  parameters:
    author: Zach Leffke, KJ4QLP
    copyright: MIT
    description: WWV Polarization Discrimination, V1
    generate_options: qt_gui
    id: wwv_xcorr_uhd_1
    output_language: python
    title: WWV Cross Correlation Monitor
  states: {}

blocks:
- name: ew_ant_label
  id: variable_qtgui_label
  parameters:
    gui_hint: main_tab@0:0,4,1,4
    label: Antenna
    type: string
    value: East/West
  states: {}
- name: ns_ant_label
  id: variable_qtgui_label
  parameters:
    gui_hint: main_tab@0:0,0,1,4
    label: Antenna
    type: string
    value: North/South
  states: {}
- name: rx_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@0:5,2,1,2
    label: Freq [Hz]
    type: real
    value: 20e6
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@0:5,0,1,2
    type: real
    value: 500e3
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: '-90 deg phase shift'
    const: complex(0,-1)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: +90 deg phase shift
    const: complex(0,1)
    type: complex
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: rx_freq
    freq_span: samp_rate
    gui_hint: main_tab@0:1,0,3,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: fosphor_qt_sink_c_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: rx_freq
    freq_span: samp_rate
    gui_hint: main_tab@0:1,4,3,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: main_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,1
    label0: Channel
    label1: Polarized
    label2: Audio
    label3: Power
    num_tabs: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@1:0,0,4,4
    label1: N/S
    label2: E/W
    label3: ''
    label4: ''
    nconnections: '4'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@1:0,4,2,4
    name: '"N/S"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@1:2,4,2,4
    name: '"E/W"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@1:6,4,2,4
    name: '"LHCP"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@1:4,4,2,4
    name: '"RHCP"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: uhd.tune_request(rx_freq, samp_rate/2)
    center_freq1: uhd.tune_request(rx_freq, samp_rate/2)
    clock_source0: gpsdo
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.41.1.11"'
    dev_args: '""'
    gain0: '0'
    gain1: '0'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:A A:B
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_sink_2_0_0
  id: virtual_sink
  parameters:
    stream_id: lhcp
  states: {}
- name: virtual_sink_2_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rhcp
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: rhcp
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: lhcp
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: rhcp
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: lhcp
  states: {}

connections:
- [blocks_add_xx_0, '0', virtual_sink_2_0_0_0, '0']
- [blocks_add_xx_0_0, '0', virtual_sink_2_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_1_0_1, '0', blocks_add_xx_0, '1']
- [uhd_usrp_source_0, '0', fosphor_qt_sink_c_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source_0, '1', fosphor_qt_sink_c_0_0, '0']
- [uhd_usrp_source_0, '1', virtual_sink_1, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_0_0, '0', blocks_add_xx_0_0, '0']
- [virtual_source_0_0_1, '0', qtgui_waterfall_sink_x_0_1_0, '0']
- [virtual_source_0_1, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_1_0, '0', blocks_multiply_const_vxx_1_0_0_0, '0']
- [virtual_source_1_0_0, '0', blocks_multiply_const_vxx_1_0_1, '0']
- [virtual_source_1_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [virtual_source_1_1, '0', qtgui_waterfall_sink_x_0_0, '0']
- [virtual_source_2, '0', qtgui_freq_sink_x_0, '2']
- [virtual_source_3, '0', qtgui_freq_sink_x_0, '3']

metadata:
  file_format: 1
