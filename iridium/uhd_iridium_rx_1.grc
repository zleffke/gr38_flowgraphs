options:
  parameters:
    author: Zach Leffke, KJ4QLP
    copyright: MIT
    description: Iridium Full Band with Fosphor
    generate_options: qt_gui
    id: uhd_iridium_rx_1
    output_language: python
    title: Iridium RX, N210, UBX-40
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,4,1,4
    type: real
    value: '20'
  states: {}
- name: bpf_taps_cc
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: samp_rate/2/decim
    low_cutoff_freq: '-samp_rate/2/decim'
    samp_rate: samp_rate
    type: complex_band_pass
    width: 500e3
    win: firdes.WIN_HAMMING
  states: {}
- name: decim
  id: variable
  parameters:
    value: '25'
  states: {}
- name: f_ring_alert
  id: variable
  parameters:
    value: 1626.270833e6
  states: {}
- name: fc_iridium
  id: variable
  parameters:
    value: 1621.25e6
  states: {}
- name: full_band_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,4
    label: '"Iridium"'
    type: string
    value: '"Full Band"'
  states: {state: disabled}
- name: iridium_rx_1_addr
  id: variable
  parameters:
    value: '"addr=10.51.2.10"'
  states: {}
- name: ring_alert_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,4
    label: '"Iridium"'
    type: string
    value: '"Ring Alert"'
  states: {}
- name: rx_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,0,1,4
    type: real
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12.5e6
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: bb_gain
    type: complex
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    gui_hint: 1,0,3,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: fosphor_qt_sink_c_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate / decim
    gui_hint: 1,0,3,8
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: f_ring_alert-fc_iridium
    decim: '25'
    samp_rate: samp_rate
    taps: bpf_taps_cc
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: uhd.tune_request(fc_iridium, samp_rate/2)
    clock_source0: external
    dc_offs_enb0: '""'
    dev_addr: iridium_rx_1_addr
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', fosphor_glfw_sink_c_0, '0']
- [analog_agc2_xx_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_multiply_const_vxx_0, '0', fosphor_qt_sink_c_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc2_xx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
