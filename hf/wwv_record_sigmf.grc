options:
  parameters:
    author: Zach Leffke
    category: Custom
    description: Generic SigMF Recorder,
    generate_options: qt_gui
    id: wwv_dual_record_sigmf
    output_language: python
    title: wwv_dual_record_sigmf
  states: {}

blocks:
- name: fn_x
  id: variable
  parameters:
    value: '"{:s}_{:s}_{:s}".format(signal_type.upper(), ant_pol_x, ts_str)'
  states: {}
- name: fn_y
  id: variable
  parameters:
    value: '"{:s}_{:s}_{:s}".format(signal_type.upper(), ant_pol_y, ts_str)'
  states: {}
- name: fp_x
  id: variable
  parameters:
    value: '"{:s}/{:s}".format(path, fn_x)'
  states: {}
- name: fp_y
  id: variable
  parameters:
    value: '"{:s}/{:s}".format(path, fn_y)'
  states: {}
- name: resamp_rate
  id: variable
  parameters:
    value: float(interp / decim * samp_rate)
  states: {}
- name: rx_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2,1,2
    type: real
    value: 10e6
  states: {}
- name: ts_str
  id: variable
  parameters:
    value: dt.strftime(dt.utcnow(), "%Y-%m-%dT%H:%M:%SZ")
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,2
    label: Antenna
    type: string
    value: '"North/South"'
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,2
    label: Antenna
    type: string
    value: '"East/West"'
  states: {}
- name: ant_pol_x
  id: parameter
  parameters:
    type: str
    value: N-S
  states: {}
- name: ant_pol_y
  id: parameter
  parameters:
    type: str
    value: E-W
  states: {}
- name: ant_type
  id: parameter
  parameters:
    type: str
    value: KJ4QLP Active HF Dipole Balun
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    num_inputs: '2'
    type: complex
  states: {state: disabled}
- name: db_type
  id: parameter
  parameters:
    type: str
    value: LFRX
  states: {}
- name: decim
  id: parameter
  parameters:
    type: intx
    value: '5'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {state: disabled}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    gui_hint: 1,0,4,4
  states: {}
- name: fosphor_qt_sink_c_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    gui_hint: 1,4,4,4
  states: {}
- name: geo_alt
  id: parameter
  parameters:
    type: eng_float
    value: '655.0'
  states: {}
- name: geo_lat
  id: parameter
  parameters:
    type: eng_float
    value: '37.206756'
  states: {}
- name: geo_lon
  id: parameter
  parameters:
    type: eng_float
    value: '-80.418876'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime as dt; import string; import math
  states: {}
- name: interp
  id: parameter
  parameters:
    type: intx
    value: '1'
  states: {}
- name: path
  id: parameter
  parameters:
    value: '"/captures/wwv"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: resamp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 5,0,2,4
    label1: '"N-S"'
    label2: '"E-W"'
    nconnections: '2'
    type: complex
    update_time: '0.0050'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-40'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 7,0,2,4
    nconnections: '2'
    size: '1024'
    srate: samp_rate / decim
    type: complex
    update_time: '0.010'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: resamp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 5,4,2,4
    int_max: '-40'
    label1: N-S
    name: '"N-S"'
    type: complex
    update_time: '0.0050'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: resamp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 7,4,2,4
    int_max: '-40'
    label1: E-W
    name: '"E-W"'
    type: complex
    update_time: '0.0050'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    fbw: ''
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    fbw: ''
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 250e3
  states: {}
- name: sigmf_sink_1
  id: sigmf_sink
  parameters:
    append: 'False'
    author: Zach Leffke, KJ4QLP
    description: WWV Dual Polarization Recorder
    field_10_key: '"ant:pol"'
    field_10_type: string
    field_10_value: ant_pol_x
    field_11_key: '"geo:lat"'
    field_11_type: string
    field_11_value: '"{:2.7f}".format(geo_lat)'
    field_12_key: '"geo:lon"'
    field_12_type: string
    field_12_value: '"{:2.7f}".format(geo_lon)'
    field_13_key: '"geo:alt"'
    field_13_type: string
    field_13_value: '"{:4.3f}".format(geo_alt)'
    field_14_key: '"misc:interpolation"'
    field_14_type: int
    field_14_value: interp
    field_15_key: '"misc:decimation"'
    field_15_type: int
    field_15_value: decim
    field_16_key: ''
    field_16_type: string
    field_16_value: ''
    field_17_key: ''
    field_17_type: string
    field_17_value: ''
    field_18_key: ''
    field_18_type: string
    field_18_value: ''
    field_19_key: ''
    field_19_type: string
    field_19_value: ''
    field_1_key: '"uhd:usrp_type"'
    field_1_type: string
    field_1_value: usrp_type
    field_20_key: ''
    field_20_type: string
    field_20_value: ''
    field_21_key: ''
    field_21_type: string
    field_21_value: ''
    field_22_key: ''
    field_22_type: string
    field_22_value: ''
    field_23_key: ''
    field_23_type: string
    field_23_value: ''
    field_24_key: ''
    field_24_type: string
    field_24_value: ''
    field_25_key: ''
    field_25_type: string
    field_25_value: ''
    field_2_key: '"uhd:db_type"'
    field_2_type: string
    field_2_value: db_type
    field_3_key: '"uhd:addr"'
    field_3_type: string
    field_3_value: usrp_addr
    field_4_key: '"uhd:subdev_spec"'
    field_4_type: string
    field_4_value: usrp_subdev_spec
    field_5_key: '"uhd:sync"'
    field_5_type: string
    field_5_value: usrp_sync
    field_6_key: '"uhd:clock_source"'
    field_6_type: string
    field_6_value: usrp_clock_source
    field_7_key: '"uhd:time_source"'
    field_7_type: string
    field_7_value: usrp_time_source
    field_8_key: '"misc:signal_type"'
    field_8_type: string
    field_8_value: signal_type
    field_9_key: '"ant:type"'
    field_9_type: string
    field_9_value: ant_type
    filename: fp_x
    hardware: N210, LFRX, KJ4QLP AHFDB Antenna
    license: MIT
    num_extra_fields: '15'
    samp_rate: resamp_rate
    time_mode: gr_sigmf.sigmf_time_mode_absolute
    type: fc32
  states: {}
- name: sigmf_sink_1_0
  id: sigmf_sink
  parameters:
    append: 'False'
    author: Zach Leffke, KJ4QLP
    description: WWV Dual Polarization Recorder
    field_10_key: '"ant:pol"'
    field_10_type: string
    field_10_value: ant_pol_y
    field_11_key: '"geo:lat"'
    field_11_type: string
    field_11_value: '"{:2.7f}".format(geo_lat)'
    field_12_key: '"geo:lon"'
    field_12_type: string
    field_12_value: '"{:2.7f}".format(geo_lon)'
    field_13_key: '"geo:alt"'
    field_13_type: string
    field_13_value: '"{:4.3f}".format(geo_alt)'
    field_14_key: '"misc:interpolation"'
    field_14_type: int
    field_14_value: interp
    field_15_key: '"misc:decimation"'
    field_15_type: int
    field_15_value: decim
    field_16_key: ''
    field_16_type: string
    field_16_value: ''
    field_17_key: ''
    field_17_type: string
    field_17_value: ''
    field_18_key: ''
    field_18_type: string
    field_18_value: ''
    field_19_key: ''
    field_19_type: string
    field_19_value: ''
    field_1_key: '"uhd:usrp_type"'
    field_1_type: string
    field_1_value: usrp_type
    field_20_key: ''
    field_20_type: string
    field_20_value: ''
    field_21_key: ''
    field_21_type: string
    field_21_value: ''
    field_22_key: ''
    field_22_type: string
    field_22_value: ''
    field_23_key: ''
    field_23_type: string
    field_23_value: ''
    field_24_key: ''
    field_24_type: string
    field_24_value: ''
    field_25_key: ''
    field_25_type: string
    field_25_value: ''
    field_2_key: '"uhd:db_type"'
    field_2_type: string
    field_2_value: db_type
    field_3_key: '"uhd:addr"'
    field_3_type: string
    field_3_value: usrp_addr
    field_4_key: '"uhd:subdev_spec"'
    field_4_type: string
    field_4_value: usrp_subdev_spec
    field_5_key: '"uhd:sync"'
    field_5_type: string
    field_5_value: usrp_sync
    field_6_key: '"uhd:clock_source"'
    field_6_type: string
    field_6_value: usrp_clock_source
    field_7_key: '"uhd:time_source"'
    field_7_type: string
    field_7_value: usrp_time_source
    field_8_key: '"misc:signal_type"'
    field_8_type: string
    field_8_value: signal_type
    field_9_key: '"ant:type"'
    field_9_type: string
    field_9_value: ant_type
    filename: fp_y
    hardware: N210, LFRX, KJ4QLP AHFDB Antenna
    license: MIT
    num_extra_fields: '15'
    samp_rate: resamp_rate
    time_mode: gr_sigmf.sigmf_time_mode_absolute
    type: fc32
  states: {}
- name: signal_type
  id: parameter
  parameters:
    type: str
    value: WWV
  states: {}
- name: timing_utils_system_time_diff_0
  id: timing_utils_system_time_diff
  parameters:
    output_diff: 'True'
    type: c
    update_time: 'False'
  states: {}
- name: timing_utils_system_time_diff_0_0
  id: timing_utils_system_time_diff
  parameters:
    output_diff: 'True'
    type: c
    update_time: 'False'
  states: {}
- name: timing_utils_system_time_tagger_0
  id: timing_utils_system_time_tagger
  parameters:
    interval: int(resamp_rate)
    type: c
  states: {}
- name: timing_utils_system_time_tagger_0_0
  id: timing_utils_system_time_tagger
  parameters:
    interval: int(resamp_rate)
    type: c
  states: {}
- name: timing_utils_usrp_gps_time_sync_0
  id: timing_utils_usrp_gps_time_sync
  parameters:
    usrp_source: uhd_usrp_source_0
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: uhd.tune_request(rx_freq, samp_rate/2)
    center_freq1: uhd.tune_request(rx_freq, samp_rate/2)
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: usrp_addr
    dev_args: '""'
    gain0: '0'
    gain1: '0'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: usrp_subdev_spec
    start_time: '-2.0'
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: usrp_addr
  id: parameter
  parameters:
    type: str
    value: '"addr=10.41.1.11"'
  states: {}
- name: usrp_clock_source
  id: parameter
  parameters:
    type: str
    value: '"External"'
  states: {}
- name: usrp_subdev_spec
  id: parameter
  parameters:
    type: str
    value: A:A A:B
  states: {}
- name: usrp_sync
  id: parameter
  parameters:
    type: str
    value: '"Unknown PPS"'
  states: {}
- name: usrp_time_source
  id: parameter
  parameters:
    type: str
    value: '"External"'
  states: {}
- name: usrp_type
  id: parameter
  parameters:
    type: str
    value: N210
  states: {}

connections:
- [fosphor_qt_sink_c_0_0, freq, timing_utils_usrp_gps_time_sync_0, in]
- [rational_resampler_xxx_0, '0', blocks_tag_debug_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', timing_utils_system_time_tagger_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_tag_debug_0_0, '1']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0, '1']
- [rational_resampler_xxx_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', timing_utils_system_time_tagger_0, '0']
- [timing_utils_system_time_diff_0, '0', blocks_tag_debug_0, '0']
- [timing_utils_system_time_diff_0, '0', qtgui_time_sink_x_0, '0']
- [timing_utils_system_time_diff_0, '0', sigmf_sink_1, '0']
- [timing_utils_system_time_diff_0, '1', qtgui_number_sink_0, '0']
- [timing_utils_system_time_diff_0_0, '0', blocks_tag_debug_0, '1']
- [timing_utils_system_time_diff_0_0, '0', qtgui_time_sink_x_0, '1']
- [timing_utils_system_time_diff_0_0, '0', sigmf_sink_1_0, '0']
- [timing_utils_system_time_diff_0_0, '1', qtgui_number_sink_0, '1']
- [timing_utils_system_time_tagger_0, '0', timing_utils_system_time_diff_0_0, '0']
- [timing_utils_system_time_tagger_0_0, '0', timing_utils_system_time_diff_0, '0']
- [uhd_usrp_source_0, '0', fosphor_qt_sink_c_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']
- [uhd_usrp_source_0, '1', fosphor_qt_sink_c_0_0, '0']
- [uhd_usrp_source_0, '1', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
