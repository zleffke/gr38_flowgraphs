options:
  parameters:
    author: Zach Leffke, KJ4QLP
    copyright: MIT
    description: WWV Polarization Discrimination, V1
    generate_options: qt_gui
    id: wwv_xcorr_uhd_1
    output_language: python
    title: WWV Cross Correlation Monitor
  states: {}

blocks:
- name: avg_len
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@2:5,0,1,2
    label: avg_len
    type: real
    value: '100'
  states: {}
- name: avg_len_pwr
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@3:2,2,1,2
    type: real
    value: '10000.0'
  states: {}
- name: decim_1
  id: variable
  parameters:
    value: '50'
  states: {}
- name: ew_ant_label
  id: variable_qtgui_label
  parameters:
    gui_hint: main_tab@0:0,4,1,4
    label: Antenna
    type: string
    value: East/West
  states: {}
- name: idx_label
  id: variable_qtgui_label
  parameters:
    gui_hint: main_tab@3:4,3,1,1
    type: real
    value: idx_max
  states: {state: disabled}
- name: idx_max
  id: variable_function_probe
  parameters:
    block_id: max_idx_probe1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {state: disabled}
- name: lpf_cut
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@1:8,0,1,2
    label: Freq [Hz]
    type: real
    value: 5e3
  states: {}
- name: nfft
  id: variable
  parameters:
    value: 1024*4
  states: {state: disabled}
- name: ns_ant_label
  id: variable_qtgui_label
  parameters:
    gui_hint: main_tab@0:0,0,1,4
    label: Antenna
    type: string
    value: North/South
  states: {}
- name: rx_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 5,2,1,2
    label: Freq [Hz]
    type: real
    value: 15e6
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: 5,0,1,2
    type: real
    value: 0.5e6
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-nfft/2.0'
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: nfft
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    vlen: nfft
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_2
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: nfft
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_keep_m_in_n_0_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: nfft
    offset: int(idx_max)
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len_pwr)
    max_iter: '4000'
    scale: 1/avg_len_pwr
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len_pwr)
    max_iter: '4000'
    scale: 1/avg_len_pwr
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len)
    max_iter: '4000'
    scale: 1.0/avg_len
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_1
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len_pwr)
    max_iter: '4000'
    scale: 1/avg_len_pwr
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len)
    max_iter: '4000'
    scale: 1.0/avg_len
    type: float
  states: {}
- name: blocks_moving_average_xx_0_2
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len_pwr)
    max_iter: '4000'
    scale: 1/avg_len_pwr
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: nfft
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/math.pi
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/avg_len_pwr
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/avg_len_pwr
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: +90 deg phase shift
    const: complex(0,1)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: +90 deg phase shift
    const: complex(0,1)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/avg_len_pwr
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/math.pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/math.pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: '-90 deg phase shift'
    const: complex(0,-1)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: '-90 deg phase shift'
    const: complex(0,-1)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/math.pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/avg_len_pwr
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: nfft
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: nfft
    type: float
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {state: disabled}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {state: disabled}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {state: disabled}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: rx_freq
    freq_span: samp_rate
    gui_hint: main_tab@0:1,0,2,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: fosphor_qt_sink_c_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: rx_freq
    freq_span: samp_rate
    gui_hint: main_tab@0:1,4,2,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: fosphor_qt_sink_c_0_1
  id: fosphor_qt_sink_c
  parameters:
    freq_center: rx_freq
    freq_span: samp_rate / decim_1
    gui_hint: main_tab@1:4,0,4,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime as dt; import string; import math; import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cut
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decim_1
    type: fir_filter_ccf
    width: .1e3
    win: firdes.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cut
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decim_1
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_BLACKMAN
  states: {}
- name: main_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,4,4
    label0: Channel
    label1: Filter + Resamp
    label2: Phase
    label3: Power
    num_tabs: '4'
  states: {}
- name: max_idx_probe1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@0:3,0,2,4
    label1: N/S
    label2: E/W
    label3: RHCP
    label4: LHCP
    nconnections: '4'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decim_1
    fc: rx_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: main_tab@1:0,0,4,4
    label1: N/S
    label2: E/W
    label3: RHCP
    label4: LHCP
    name: '"Filtered and Resampled"'
    nconnections: '4'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: nfft
    gui_hint: main_tab@3:0,4,2,4
    label1: samp offset
    name: '"sample offset"'
    size: '1'
    type: float
    update_time: '0.010'
    xmax: '500'
    xmin: '-500'
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '720'
    gui_hint: main_tab@3:2,4,2,4
    label1: phase [deg]
    name: '"phase"'
    size: '1'
    type: float
    update_time: '0.010'
    xmax: '180'
    xmin: '-180'
  states: {state: disabled}
- name: qtgui_histogram_sink_x_1_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '2000'
    grid: 'True'
    gui_hint: main_tab@2:0,2,2,2
    label1: RHCP
    name: '"Phase"'
    size: '100'
    type: float
    xmax: '360'
    xmin: '-360'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: main_tab@3:4,4,1,4
    label1: Delay
    type: float
    unit1: '[samp]'
    update_time: '0.010'
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    color2: ("blue", "red")
    color3: ("blue", "red")
    color4: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: main_tab@3:2,0,2,2
    label1: '"N/S"'
    label2: '"E/W"'
    label3: '"RHCP"'
    label4: '"LHCP"'
    max: '-140'
    min: '-40'
    name: RSSI
    nconnections: '4'
    type: float
    update_time: '0.010'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: main_tab@2:0,0,2,2
    nconnections: '2'
    size: 1024 * 32
    srate: samp_rate / decim_1
    type: complex
    update_time: '0.010'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: main_tab@2:2,0,2,4
    label1: NS
    label2: EW
    label3: NS-EW
    name: '"Original"'
    nconnections: '3'
    size: 1024*8
    srate: samp_rate
    type: float
    update_time: '0.010'
    ylabel: Phase
    ymax: '360'
    ymin: '-360'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: main_tab@3:0,0,2,4
    label1: N/S
    label2: E/W
    label3: RHCP
    label4: LHCP
    nconnections: '4'
    size: '1024'
    srate: samp_rate / decim_1
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: main_tab@3:0,0,4,4
    showports: 'True'
    vlen: nfft
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@0:3,4,1,2
    name: '"N/S"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@0:3,6,1,2
    name: '"E/W"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim_1
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@1:2,4,2,4
    name: '"E/W"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@0:4,6,1,2
    name: '"LHCP"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim_1
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@1:6,4,2,4
    name: '"LHCP"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim_1
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@1:0,4,2,4
    name: '"N/S"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@0:4,4,1,2
    name: '"RHCP"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim_1
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@1:4,4,2,4
    name: '"RHCP"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_1
    fbw: ''
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: decim_1
    fbw: ''
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: uhd.tune_request(rx_freq, samp_rate/4)
    center_freq1: uhd.tune_request(rx_freq, samp_rate/4)
    clock_source0: internal
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.41.1.11"'
    dev_args: '""'
    gain0: '0'
    gain1: '0'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:A A:B
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_sink_2_0_0
  id: virtual_sink
  parameters:
    stream_id: lhcp
  states: {}
- name: virtual_sink_2_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rhcp
  states: {}
- name: virtual_sink_2_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rhcp_filt
  states: {}
- name: virtual_sink_2_0_0_1
  id: virtual_sink
  parameters:
    stream_id: lhcp_filt
  states: {}
- name: virtual_sink_2_1
  id: virtual_sink
  parameters:
    stream_id: x_corr
  states: {state: disabled}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: x_corr_cc
  states: {state: disabled}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: ns_filt
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: ew_filt
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: ns_filt
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: rhcp_filt
  states: {state: disabled}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: rhcp
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: rhcp_filt
  states: {}
- name: virtual_source_0_0_1_2_0_0
  id: virtual_source
  parameters:
    stream_id: lhcp_filt
  states: {}
- name: virtual_source_0_0_1_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: ew_filt
  states: {}
- name: virtual_source_0_0_1_2_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: lhcp_filt
  states: {}
- name: virtual_source_0_0_2
  id: virtual_source
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_source_0_0_3
  id: virtual_source
  parameters:
    stream_id: ns_filt
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: ns_filt
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: x_corr_cc
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: lhcp
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: lhcp_filt
  states: {}
- name: virtual_source_1_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: rhcp_filt
  states: {}
- name: virtual_source_1_0_0_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: ns_filt
  states: {}
- name: virtual_source_1_0_0_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: rhcp_filt
  states: {}
- name: virtual_source_1_0_0_1
  id: virtual_source
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_source_1_0_0_2
  id: virtual_source
  parameters:
    stream_id: ew_filt
  states: {}
- name: virtual_source_1_0_1
  id: virtual_source
  parameters:
    stream_id: ew_filt
  states: {}
- name: virtual_source_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: lhcp_filt
  states: {state: disabled}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: ew_filt
  states: {}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: x_corr
  states: {state: disabled}

connections:
- [blocks_add_const_vxx_0, '0', max_idx_probe1, '0']
- [blocks_add_const_vxx_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_2_0_0_0, '0']
- [blocks_add_xx_0_0, '0', virtual_sink_2_0_0, '0']
- [blocks_add_xx_0_0_0, '0', virtual_sink_2_0_0_1, '0']
- [blocks_add_xx_0_1, '0', virtual_sink_2_0_0_0_0, '0']
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [blocks_complex_to_arg_0_0_0_0_1, '0', blocks_multiply_const_vxx_1_0_0_2_0, '0']
- [blocks_complex_to_arg_0_0_0_0_1, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_arg_0_0_0_2, '0', blocks_multiply_const_vxx_1_0_0_2, '0']
- [blocks_complex_to_arg_0_0_0_2, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_mag_0, '0', virtual_sink_2_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_moving_average_xx_0_0_1, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_moving_average_xx_0_2, '0']
- [blocks_keep_m_in_n_0_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_sub_xx_1_0, '1']
- [blocks_moving_average_xx_0_0_1, '0', blocks_multiply_const_vxx_1_0_0_1, '0']
- [blocks_moving_average_xx_0_1, '0', blocks_sub_xx_1_0, '0']
- [blocks_moving_average_xx_0_2, '0', blocks_multiply_const_vxx_1_0_3, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_2, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_histogram_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_1_0_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [blocks_multiply_const_vxx_1_0_0_1, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0_2, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_multiply_const_vxx_1_0_0_2, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0_2_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0_2_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_multiply_const_vxx_1_0_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1_0_1_0, '0', blocks_add_xx_0_1, '1']
- [blocks_multiply_const_vxx_1_0_2, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_multiply_const_vxx_1_0_3, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink_0_0, '1']
- [blocks_nlog10_ff_0_0, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_number_sink_0_0, '3']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_time_sink_x_0_1, '3']
- [blocks_nlog10_ff_0_1, '0', qtgui_number_sink_0_0, '2']
- [blocks_nlog10_ff_0_1, '0', qtgui_time_sink_x_0_1, '2']
- [blocks_short_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_1, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_1_0_2, '0']
- [blocks_sub_xx_1_0, '0', qtgui_histogram_sink_x_1_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_keep_m_in_n_0_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_2, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_2, '0', virtual_sink_4, '0']
- [low_pass_filter_0, '0', virtual_sink_6, '0']
- [low_pass_filter_1, '0', virtual_sink_7, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_1, '0']
- [uhd_usrp_source_0, '0', fosphor_qt_sink_c_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source_0, '1', fosphor_qt_sink_c_0_0, '0']
- [uhd_usrp_source_0, '1', virtual_sink_1, '0']
- [virtual_source_0_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_0_0, '0', blocks_add_xx_0_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_add_xx_0_0_0, '0']
- [virtual_source_0_0_0_1, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_0_1, '0', qtgui_freq_sink_x_0, '2']
- [virtual_source_0_0_1, '0', qtgui_waterfall_sink_x_0_1_0, '0']
- [virtual_source_0_0_1_0, '0', qtgui_freq_sink_x_0_0, '2']
- [virtual_source_0_0_1_0, '0', qtgui_waterfall_sink_x_0_1_0_0, '0']
- [virtual_source_0_0_1_2_0_0, '0', blocks_complex_to_arg_0_0_0_0_1, '0']
- [virtual_source_0_0_1_2_0_0, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_0_0_1_2_0_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [virtual_source_0_0_1_2_0_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [virtual_source_0_0_2, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0_0_3, '0', blocks_add_xx_0_1, '0']
- [virtual_source_0_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_1, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0_1_0, '0', fosphor_qt_sink_c_0_1, '0']
- [virtual_source_0_1_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0_1_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [virtual_source_0_3, '0', blocks_complex_to_arg_0, '0']
- [virtual_source_0_3, '0', blocks_vector_to_stream_0_0, '0']
- [virtual_source_1_0, '0', blocks_multiply_const_vxx_1_0_0_0, '0']
- [virtual_source_1_0_0, '0', blocks_multiply_const_vxx_1_0_1, '0']
- [virtual_source_1_0_0_0, '0', qtgui_freq_sink_x_0, '3']
- [virtual_source_1_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [virtual_source_1_0_0_0_0, '0', qtgui_freq_sink_x_0_0, '3']
- [virtual_source_1_0_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0_0_0, '0']
- [virtual_source_1_0_0_0_1_0_0, '0', blocks_complex_to_arg_0_0_0_2, '0']
- [virtual_source_1_0_0_0_1_0_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_1_0_0_0_1_0_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_1_0_0_0_1_0_0_0_0, '0', blocks_complex_to_mag_squared_0_1, '0']
- [virtual_source_1_0_0_1, '0', rational_resampler_xxx_1, '0']
- [virtual_source_1_0_0_2, '0', blocks_multiply_const_vxx_1_0_1_0, '0']
- [virtual_source_1_0_1, '0', blocks_multiply_const_vxx_1_0_0_0_0, '0']
- [virtual_source_1_0_1_0, '0', blocks_stream_to_vector_1, '0']
- [virtual_source_1_1, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_1_1, '0', qtgui_waterfall_sink_x_0_0, '0']
- [virtual_source_1_1_0, '0', qtgui_freq_sink_x_0_0, '1']
- [virtual_source_1_1_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [virtual_source_2_0_0, '0', blocks_argmax_xx_0, '0']

metadata:
  file_format: 1
