options:
  parameters:
    generate_options: qt_gui
    id: uhd_hf_am
    output_language: python
  states: {}

blocks:
- name: audio_attack
  id: variable_qtgui_entry
  parameters:
    gui_hint: 9,1,1,1
    type: real
    value: '1000'
  states: {}
- name: audio_decay
  id: variable_qtgui_entry
  parameters:
    gui_hint: 9,2,1,1
    type: real
    value: '100'
  states: {}
- name: audio_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 9,4,1,1
    type: real
    value: '1'
  states: {}
- name: audio_max_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 9,5,1,1
    type: real
    value: '1'
  states: {}
- name: audio_ref
  id: variable_qtgui_entry
  parameters:
    gui_hint: 9,3,1,1
    type: real
    value: '1'
  states: {}
- name: coarse_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,4
    orient: Qt.Horizontal
    start: '-100e3'
    step: '1'
    stop: 100e3
    value: '0'
  states: {}
- name: decay_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,6,1,1
    label0: Fast
    label1: Medium
    label2: Slow
    num_opts: '3'
    option0: '100e-6'
    option1: '65e-3'
    option2: '20e-3'
    orient: Qt.QHBoxLayout
    type: real
    value: '100e-6'
    widget: radio_buttons
  states: {}
- name: decim
  id: variable
  parameters:
    value: samp_rate/1e3
  states: {}
- name: fine_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,4
    orient: Qt.Horizontal
    start: '-1e3'
    step: '1'
    stop: 1e3
    value: '0'
  states: {}
- name: freq_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 5,4,1,1
    label: Tuned Freq
    type: real
    value: rx_freq+fine_freq+coarse_freq
  states: {}
- name: interp
  id: variable
  parameters:
    value: '48'
  states: {}
- name: lpf_cutoff
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,5,1,1
    num_opts: '4'
    option0: 2e3
    option1: 3e3
    option2: 4e3
    option3: 8e3
    type: real
    value: 2e3
  states: {}
- name: lpf_cutoff
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,5,1,1
    type: real
    value: 5e3
  states: {state: disabled}
- name: pll_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 9,6,1,1
    type: real
    value: '100'
  states: {}
- name: pll_lbw
  id: variable_qtgui_entry
  parameters:
    gui_hint: 9,7,1,1
    type: real
    value: '200'
  states: {}
- name: rx_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,0,1,1
    type: real
    value: 3.993e6
  states: {state: disabled}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,4
    orient: Qt.Horizontal
    start: .2e6
    step: 100e3
    stop: 100e6
    value: 1.0e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: selection
  id: variable
  parameters:
    value: ((1,0,0),(0,1,0),(0,0,1))
  states: {}
- name: ssb_am
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,4,1,1
    label0: SSB
    label1: AM
    label2: AM*
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: usb_lsb
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,5,1,1
    label0: USB
    label1: LSB
    num_opts: '2'
    option0: '-1'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '-1'
    widget: radio_buttons
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,4
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '100'
    value: '1'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: decay_rate
    gain: '1000'
    max_gain: '65000'
    reference: '.3'
    type: complex
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: audio_attack
    decay_rate: audio_decay
    gain: audio_gain
    max_gain: audio_max_gain
    reference: audio_ref
    type: float
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: math.pi/pll_freq
    min_freq: '-math.pi/pll_freq'
    w: math.pi/pll_lbw
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1 * (fine_freq+coarse_freq)'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1.5e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/decim*interp/3
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1.5e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/decim*interp/3
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1/1000.0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: usb_lsb
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100000'
    type: float
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: (selection[ssb_am],)
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: float
  states: {}
- name: blocks_multiply_matrix_xx_0_0_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: (selection[ssb_am],)
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: rx_freq
    freq_span: samp_rate
  states: {state: disabled}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: rx_freq
    freq_span: samp_rate/int(samp_rate/1e3)*200
    gui_hint: 0,0,4,4
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.5e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate/decim*interp/3
    type: interp_fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cutoff
    decim: '3'
    gain: '1'
    samp_rate: samp_rate/decim*interp
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.5e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate/decim*interp/3
    type: interp_fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim * interp
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,4,4,4
    label1: pre-d
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim * interp/3
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 6,4,3,2
    legend: 'False'
    showports: 'True'
    type: complex
    update_time: '0.0010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 5,6,1,1
    label1: '"RSSI"'
    max: '50'
    min: '0'
    name: ''
    type: float
    update_time: '0.010'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 8,0,1,4
    label1: ''
    size: '1024'
    srate: samp_rate/decim*interp/3
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 6,6,3,2
    label1: ''
    size: '1024'
    srate: samp_rate/decim*interp/3/4
    type: float
    update_time: '0.010'
    ymax: '100'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(decim)
    fbw: ''
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/1e3)
    fbw: ''
    interp: '200'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    fbw: ''
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(rx_freq)
    clock_source0: gpsdo
    dc_offs_enb0: 'True'
    dev_addr: '"addr=10.41.1.11"'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: pc_clock
    time_source0: gpsdo
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: ssb
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: am_pll
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: am
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: ssb
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: am
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: am_pll
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_multiply_xx_0, '0']
- [analog_agc2_xx_0, '0', fosphor_glfw_sink_c_0, '0']
- [analog_agc2_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_agc2_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_real_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_multiply_matrix_xx_0_0_0, '2']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_add_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_complex_to_float_0, '0', low_pass_filter_0, '0']
- [blocks_complex_to_float_0, '1', low_pass_filter_0_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_0_0_0, '0']
- [blocks_complex_to_real_0_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_matrix_xx_0, '0', analog_agc2_xx_0_0, '0']
- [blocks_multiply_matrix_xx_0_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_matrix_xx_0_0_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1_0, '0', blocks_multiply_const_vxx_1, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_1, '0']
- [low_pass_filter_0_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0_1, '0', blocks_multiply_xx_1_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', fosphor_qt_sink_c_0, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_1, '0', analog_agc2_xx_0, '0']
- [virtual_source_0_0, '0', analog_pll_carriertracking_cc_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_float_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_real_0_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_matrix_xx_0_0_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_matrix_xx_0_0_0, '1']
- [virtual_source_0_0_0, '0', blocks_multiply_matrix_xx_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_multiply_matrix_xx_0, '1']
- [virtual_source_0_0_0_0_0, '0', blocks_multiply_matrix_xx_0, '2']

metadata:
  file_format: 1
