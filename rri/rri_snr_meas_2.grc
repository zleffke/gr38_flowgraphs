options:
  parameters:
    author: zleffke
    generate_options: qt_gui
    id: rri_snr_measurement
    output_language: python
    title: RRI SNR Measurement
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: '1.0e+07'
  states: {}
- name: fr_ratio
  id: variable
  parameters:
    value: rri_samp_rate / 32e3
  states: {}
- name: k
  id: variable
  parameters:
    value: '-10*math.log10(nfft)'
  states: {}
- name: rri_samp_rate
  id: variable
  parameters:
    value: '62500.33933'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: rri_samp_rate / fr_ratio
  states: {}
- name: throttle
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 8e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: avg_len
  id: parameter
  parameters:
    type: eng_float
    value: '1024'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len)
    max_iter: '4000'
    scale: 1.0/(avg_len)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len)
    max_iter: '4000'
    scale: 1.0/(avg_len)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len)
    max_iter: '4000'
    scale: 1.0/(avg_len)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len)
    max_iter: '4000'
    scale: 1.0/(avg_len)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: k+10*math.log10(decim)*0
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: k+10*math.log10(decim)*0
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: k
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: k
    n: '10'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: ''
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: rri_samp_rate*throttle
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: rri_samp_rate*throttle
    type: complex
  states: {}
- name: decim
  id: parameter
  parameters:
    type: intx
    value: '16'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime as dt; import string; import math; import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_bw
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_bw
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_bw
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_bw
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: lpf_bw
  id: parameter
  parameters:
    type: eng_float
    value: 1.5e3
  states: {}
- name: main_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,4,4
    label0: Pre-d
    label1: Power
    label2: Noise
    label3: SNR
    num_tabs: '4'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: fr_ratio
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: fr_ratio
    type: complex
  states: {}
- name: nfft
  id: parameter
  parameters:
    type: intx
    value: '2048'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: nfft
    grid: 'True'
    gui_hint: main_tab@0:0,0,4,4
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: main_tab@0:4,3,2,1
    label1: P1
    label2: P2
    label3: N1
    label4: N2
    nconnections: '4'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: main_tab@0:6,3,1,1
    label1: SNR1
    label2: SNR2
    max: '60'
    min: '0'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: main_tab@0:4,0,2,3
    label1: PWR1
    label2: PWR2
    label3: NOISE1
    label4: NOISE2
    nconnections: '4'
    size: '64'
    srate: samp_rate / decim
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: main_tab@0:6,0,1,3
    label1: SNR1
    label2: SNR2
    nconnections: '2'
    size: 64*8*2
    srate: samp_rate / decim
    type: float
  states: {}
- name: sigmf_source_0
  id: sigmf_source
  parameters:
    filename: /home/zleffke/captures/rri/wwv/20171023_083229/RRI_CHAN-A_20171023_083229_083326.sigmf-data
    repeat: 'False'
    type: fc32
  states: {}
- name: sigmf_source_1
  id: sigmf_source
  parameters:
    filename: /home/zleffke/captures/rri/wwv/20171023_083229/RRI_CHAN-B_20171023_083229_083326.sigmf-data
    repeat: 'False'
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: dipole1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: dipole2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: pwr_dp1
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: noise_dp1
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: pwr_dp2
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: noise_dp2
  states: {}
- name: virtual_source_0_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: dipole1
  states: {}
- name: virtual_source_1_0_1_0_1
  id: virtual_source
  parameters:
    stream_id: dipole2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: pwr_dp1
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: pwr_dp2
  states: {}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: pwr_dp2
  states: {}
- name: virtual_source_2_0_1
  id: virtual_source
  parameters:
    stream_id: noise_dp2
  states: {}
- name: virtual_source_2_0_1_0
  id: virtual_source
  parameters:
    stream_id: noise_dp1
  states: {}
- name: virtual_source_2_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: noise_dp1
  states: {}
- name: virtual_source_2_0_1_1
  id: virtual_source
  parameters:
    stream_id: noise_dp2
  states: {}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: pwr_dp1
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_moving_average_xx_0_1, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0_0_0_0, '0']
- [blocks_nlog10_ff_0, '0', virtual_sink_2, '0']
- [blocks_nlog10_ff_0_0, '0', virtual_sink_3, '0']
- [blocks_nlog10_ff_0_0_0, '0', virtual_sink_3_0, '0']
- [blocks_nlog10_ff_0_1, '0', virtual_sink_2_0, '0']
- [blocks_sub_xx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_sub_xx_0_0, '0', qtgui_number_sink_0_0, '1']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_throttle_0, '0', mmse_resampler_xx_0_0, '0']
- [blocks_throttle_0_0, '0', mmse_resampler_xx_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_complex_to_mag_squared_0_1, '0']
- [low_pass_filter_0_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_freq_sink_x_1, '1']
- [mmse_resampler_xx_0, '0', virtual_sink_1, '0']
- [mmse_resampler_xx_0_0, '0', qtgui_freq_sink_x_1, '0']
- [mmse_resampler_xx_0_0, '0', virtual_sink_0, '0']
- [sigmf_source_0, '0', blocks_tag_debug_0, '0']
- [sigmf_source_0, '0', blocks_throttle_0, '0']
- [sigmf_source_0, meta, blocks_message_debug_0, print]
- [sigmf_source_1, '0', blocks_tag_debug_0, '1']
- [sigmf_source_1, '0', blocks_throttle_0_0, '0']
- [sigmf_source_1, meta, blocks_message_debug_0, print]
- [virtual_source_0_0_0_1_1, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0_0_1_1, '0', low_pass_filter_0, '0']
- [virtual_source_1_0_1_0_1, '0', blocks_multiply_xx_1, '0']
- [virtual_source_1_0_1_0_1, '0', low_pass_filter_0_0, '0']
- [virtual_source_2, '0', qtgui_number_sink_0, '0']
- [virtual_source_2, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_2_0, '0', qtgui_number_sink_0, '1']
- [virtual_source_2_0, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_2_0_0, '0', blocks_sub_xx_0_0, '0']
- [virtual_source_2_0_1, '0', qtgui_number_sink_0, '3']
- [virtual_source_2_0_1, '0', qtgui_time_sink_x_0, '3']
- [virtual_source_2_0_1_0, '0', qtgui_number_sink_0, '2']
- [virtual_source_2_0_1_0, '0', qtgui_time_sink_x_0, '2']
- [virtual_source_2_0_1_0_0, '0', blocks_sub_xx_0, '1']
- [virtual_source_2_0_1_1, '0', blocks_sub_xx_0_0, '1']
- [virtual_source_2_1, '0', blocks_sub_xx_0, '0']

metadata:
  file_format: 1
