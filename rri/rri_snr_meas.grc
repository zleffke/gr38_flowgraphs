options:
  parameters:
    author: zleffke
    generate_options: qt_gui
    id: rri_phase_1
    output_language: python
    title: RRI Phase Comparison
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: '1.0e+07'
  states: {}
- name: fr_ratio
  id: variable
  parameters:
    value: rri_samp_rate / 32e3
  states: {}
- name: idx_max
  id: variable_function_probe
  parameters:
    block_id: max_idx_probe1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {state: disabled}
- name: rri_samp_rate
  id: variable
  parameters:
    value: '62500.33933'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: rri_samp_rate / fr_ratio
  states: {}
- name: throttle
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 8e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: avg_len
  id: parameter
  parameters:
    type: eng_float
    value: '256'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-nfft/2.0'
    type: float
  states: {state: disabled}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: nfft
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    vlen: nfft
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: nfft
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: nfft
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: nfft
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_0_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: nfft
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_0_1
  id: blocks_max_xx
  parameters:
    type: float
    vlen: nfft
    vlen_out: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len)
    max_iter: '4000'
    scale: 1.0/(avg_len)/nfft
    type: float
    vlen: nfft
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len)
    max_iter: '4000'
    scale: 1.0/(avg_len)/nfft
    type: float
    vlen: nfft
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len)
    max_iter: '4000'
    scale: 1.0/(avg_len)/nfft
    type: float
    vlen: nfft
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: int(avg_len)
    max_iter: '4000'
    scale: 1.0/(avg_len)/nfft
    type: float
    vlen: nfft
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: nfft
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/math.pi
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-10*math.log10(nfft)'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '-10*math.log10(nfft)'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '-10*math.log10(nfft)'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '-10*math.log10(nfft)'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: ''
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: rri_samp_rate*throttle
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: rri_samp_rate*throttle
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: nfft
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: nfft
    type: float
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {state: disabled}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_1_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {state: disabled}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: fosphor_qt_sink_c_0_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: fc
    freq_span: samp_rate
    gui_hint: main_tab@2:1,4,2,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: fosphor_qt_sink_c_0_1
  id: fosphor_qt_sink_c
  parameters:
    freq_center: fc
    freq_span: samp_rate
    gui_hint: main_tab@2:1,0,2,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime as dt; import string; import math; import numpy as np
  states: {}
- name: main_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,4,4
    label0: Pre-d
    label1: Power
    label2: Noise
    label3: SNR
    num_tabs: '4'
  states: {}
- name: max_idx_probe1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {state: disabled}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: fr_ratio
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: fr_ratio
    type: complex
  states: {}
- name: nfft
  id: parameter
  parameters:
    type: intx
    value: '2048'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,0,4,8
    label1: Dipole X
    label2: Dipole Y
    nconnections: '2'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: main_tab@0:0,0,4,4
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: nfft
    gui_hint: main_tab@3:0,4,2,4
    label1: samp offset
    name: '"sample offset"'
    size: '1'
    type: float
    update_time: '0.010'
    xmax: '500'
    xmin: '-500'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: main_tab@3:4,4,1,4
    label1: Delay
    type: float
    unit1: '[samp]'
    update_time: '0.010'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: main_tab@0:4,0,2,4
    label1: PWR1
    label2: PWR2
    label3: NOISE1
    label4: NOISE2
    nconnections: '4'
    size: '64'
    srate: samp_rate / nfft
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: main_tab@4:0,0,4,4
    showports: 'True'
    vlen: nfft
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '4096'
    gui_hint: 4,4,2,4
    name: '"Dipole 2"'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: sigmf_source_0
  id: sigmf_source
  parameters:
    filename: /home/zleffke/captures/rri/wwv/20171023_083229/RRI_CHAN-A_20171023_083229_083326.sigmf-data
    repeat: 'True'
    type: fc32
  states: {}
- name: sigmf_source_1
  id: sigmf_source
  parameters:
    filename: /home/zleffke/captures/rri/wwv/20171023_083229/RRI_CHAN-B_20171023_083229_083326.sigmf-data
    repeat: 'True'
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: dipole1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: dipole2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: pwr_dp1
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: noise_dp1
  states: {}
- name: virtual_sink_2_1
  id: virtual_sink
  parameters:
    stream_id: x_corr
  states: {state: disabled}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: pwr_dp2
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: noise_dp2
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: x_corr_cc
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rhcp
  states: {state: disabled}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: dipole1
  states: {state: disabled}
- name: virtual_source_0_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: dipole1
  states: {}
- name: virtual_source_0_0_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: dipole1
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: x_corr_cc
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: lhcp
  states: {state: disabled}
- name: virtual_source_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: dipole2
  states: {state: disabled}
- name: virtual_source_1_0_1_0_1
  id: virtual_source
  parameters:
    stream_id: dipole2
  states: {}
- name: virtual_source_1_0_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: dipole2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: pwr_dp1
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: pwr_dp2
  states: {}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: x_corr
  states: {state: disabled}
- name: virtual_source_2_0_1
  id: virtual_source
  parameters:
    stream_id: noise_dp2
  states: {}
- name: virtual_source_2_0_1_0
  id: virtual_source
  parameters:
    stream_id: noise_dp1
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_const_vxx_0, '0', max_idx_probe1, '0']
- [blocks_add_const_vxx_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_mag_0, '0', virtual_sink_2_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_max_xx_0, '0', virtual_sink_2, '0']
- [blocks_max_xx_0_0, '0', virtual_sink_3, '0']
- [blocks_max_xx_0_0_0, '0', virtual_sink_3_0, '0']
- [blocks_max_xx_0_1, '0', virtual_sink_2_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_moving_average_xx_0_1, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_2, '0']
- [blocks_multiply_xx_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_stream_to_vector_1_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_max_xx_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_max_xx_0_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', blocks_max_xx_0_0_0, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_max_xx_0_1, '0']
- [blocks_short_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_1, '0']
- [blocks_stream_to_vector_1_0, '0', fft_vxx_1_0, '0']
- [blocks_stream_to_vector_1_0_0, '0', fft_vxx_1_0_0, '0']
- [blocks_throttle_0, '0', mmse_resampler_xx_0_0, '0']
- [blocks_throttle_0_0, '0', mmse_resampler_xx_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0_0, '0', blocks_complex_to_mag_squared_0_1, '0']
- [fft_vxx_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_1_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_1_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [fft_vxx_2, '0', blocks_complex_to_arg_0, '0']
- [fft_vxx_2, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_2, '0', virtual_sink_4, '0']
- [mmse_resampler_xx_0, '0', qtgui_freq_sink_x_1, '1']
- [mmse_resampler_xx_0, '0', virtual_sink_1, '0']
- [mmse_resampler_xx_0_0, '0', qtgui_freq_sink_x_1, '0']
- [mmse_resampler_xx_0_0, '0', virtual_sink_0, '0']
- [sigmf_source_0, '0', blocks_tag_debug_0, '0']
- [sigmf_source_0, '0', blocks_throttle_0, '0']
- [sigmf_source_0, meta, blocks_message_debug_0, print]
- [sigmf_source_1, '0', blocks_tag_debug_0, '1']
- [sigmf_source_1, '0', blocks_throttle_0_0, '0']
- [sigmf_source_1, meta, blocks_message_debug_0, print]
- [virtual_source_0, '0', fosphor_qt_sink_c_0_1, '0']
- [virtual_source_0_0_0_1, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_0_0_1_1, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_0_0_0_1_1_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_3, '0', blocks_vector_to_stream_0_0, '0']
- [virtual_source_1, '0', fosphor_qt_sink_c_0_0_0, '0']
- [virtual_source_1_0_1_0, '0', blocks_stream_to_vector_1, '0']
- [virtual_source_1_0_1_0_1, '0', blocks_stream_to_vector_1_0, '0']
- [virtual_source_1_0_1_0_1_0, '0', blocks_multiply_xx_1, '0']
- [virtual_source_2, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_2_0, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_2_0_0, '0', blocks_argmax_xx_0, '0']
- [virtual_source_2_0_1, '0', qtgui_time_sink_x_0, '3']
- [virtual_source_2_0_1_0, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
