options:
  parameters:
    author: zleffke
    generate_options: qt_gui
    id: rri_simple
    output_language: python
    title: Simple RRI Test
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: '4350023.613248409'
  states: {}
- name: fr_ratio
  id: variable
  parameters:
    value: rri_samp_rate / 32e3
  states: {}
- name: rri_samp_rate
  id: variable
  parameters:
    value: '62500.33933'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: rri_samp_rate / fr_ratio
  states: {}
- name: throttle
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '10'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/zleffke/github/zleffke/python/python_scripts/rri/dipole2.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/zleffke/github/zleffke/python/python_scripts/rri/dipole1.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: rri_samp_rate*throttle
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: rri_samp_rate*throttle
    type: complex
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: fc
    freq_span: samp_rate
    gui_hint: 4,0,2,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: fosphor_qt_sink_c_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: fc
    freq_span: samp_rate
    gui_hint: 4,4,2,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: fr_ratio
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: fr_ratio
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,0,4,8
    label1: Dipole X
    label2: Dipole Y
    nconnections: '2'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '4096'
    gui_hint: 4,0,2,4
    name: '"Dipole 1"'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '4096'
    gui_hint: 4,4,2,4
    name: '"Dipole 2"'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', mmse_resampler_xx_0_0, '0']
- [blocks_throttle_0_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', fosphor_qt_sink_c_0_0, '0']
- [mmse_resampler_xx_0_0, '0', fosphor_qt_sink_c_0, '0']

metadata:
  file_format: 1
