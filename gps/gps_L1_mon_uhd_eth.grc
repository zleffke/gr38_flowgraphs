options:
  parameters:
    author: Zach Leffke, KJ4QLP
    copyright: MIT
    description: Iridium Full Band with Fosphor
    generate_options: qt_gui
    id: gps_L1_mon_uhd_eth
    output_language: python
    title: Iridium RX, N210, UBX-40
  states: {}

blocks:
- name: L1Hunt_addr
  id: variable
  parameters:
    value: '"addr=10.41.1.13"'
  states: {}
- name: bpf_taps_cc
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: samp_rate/2/decim
    low_cutoff_freq: '-samp_rate/2/decim'
    samp_rate: samp_rate
    type: complex_band_pass
    width: 500e3
    win: firdes.WIN_HAMMING
  states: {}
- name: decim
  id: variable
  parameters:
    value: '125'
  states: {}
- name: fc_gps_l1
  id: variable
  parameters:
    value: 1575.42e6
  states: {}
- name: fc_interferer
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '-420e3'
  states: {}
- name: full_band_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,4
    label: '"GPS"'
    type: string
    value: '"L1 Full Band"'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: iridium_rx_1_addr
  id: variable
  parameters:
    value: '"addr=10.51.2.10"'
  states: {}
- name: narrow_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,4
    label: '"GPS"'
    type: string
    value: '"L1 - Narrow"'
  states: {}
- name: rx_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,0,1,4
    type: real
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: uhd_fc_tune
  id: variable
  parameters:
    value: uhd.tune_request(fc_gps_l1, samp_rate/2)
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.1'
    type: complex
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    gui_hint: 1,0,3,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fc_interferer
    decim: decim
    samp_rate: samp_rate
    taps: bpf_taps_cc
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim * interp
    fc: fc_gps_l1 + fc_interferer
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,4,1,4
    legend: 'False'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decim*interp
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,4,2,4
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: ''
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: uhd_fc_tune
    clock_source0: external
    dc_offs_enb0: '""'
    dev_addr: L1Hunt_addr
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', fosphor_qt_sink_c_0, '0']
- [analog_agc2_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', analog_agc2_xx_0, '0']

metadata:
  file_format: 1
